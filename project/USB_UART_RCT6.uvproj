# Keil uVision project USB_UART_RCT6.uvproj, settings and files
target koing2010 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: USB_JF24D
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\startup;..\user;..\periphlib\inc;..\periphlib\src;F:\my_project;..\mine;..\usb\include;..\usb\library\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c
    ../startup/startup/: startup_stm32f10x_md.s
  group periphlib
    ../periphlib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c stm32f10x_it.c
    ../usb/source/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group mine
    ../mine/: loadfalsh.c
  group usb_lib
    ../usb/library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group readme
    ../: readme.txt
